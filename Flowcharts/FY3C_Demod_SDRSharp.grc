options:
  parameters:
    author: MB
    generate_options: qt_gui
    id: AHRPT_FY3AB_Airspy_demodulator
    output_language: python
    title: AHRPT_FY3AB_Airspy_demodulator
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 1704.500000e6
  states: {}
- name: clock_alpha
  id: variable_qtgui_range
  parameters:
    label: Clock Alpha
    min_len: '150'
    orient: Qt.Horizontal
    start: '1e-3'
    step: '1e-5'
    stop: '10e-3'
    value: '8.7e-3'
  states: {}
- name: pll_alpha
  id: variable_qtgui_range
  parameters:
    label: PLL Alpha
    min_len: '150'
    orient: Qt.Horizontal
    start: '0.00100'
    step: '0.00001'
    stop: '0.10000'
    value: '0.00200'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 6e6
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: sps
  id: variable
  parameters:
    value: (samp_rate*1.0)/(symbol_rate*1.0)
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: 3900.0*2/3*1000
  states: {}
- name: analog_agc_xx_0_0
  id: analog_agc_xx
  parameters:
    gain: 0.5/32768.0
    max_gain: '4000'
    rate: '0.0010e-3'
    reference: '1'
    type: complex
  states: {}
- name: analog_rail_ff_0
  id: analog_rail_ff
  parameters:
    hi: '1'
    lo: '-1'
  states: {}
- name: blocks_complex_to_float_1
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    repeat: 'False'
    type: short
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '127'
  states: {}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    type: float
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    vector_input: 'False'
  states: {}
- name: blocks_throttle_0_0_1_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate*100
    type: complex
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: clock_alpha
    gain_omega: clock_alpha**2/4.0
    mu: '0.5'
    omega: sps
    omega_relative_limit: '0.005'
    type: complex
  states: {}
- name: digital_cma_equalizer_cc_0
  id: digital_cma_equalizer_cc
  parameters:
    modulus: '1'
    mu: '0.001'
    num_taps: '15'
    sps: '1'
  states: {state: bypassed}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: pll_alpha
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    color1: '"dark red"'
    grid: 'True'
    label1: Constellation diagram
    marker1: '1'
    name: FY3A/B
    size: '1024'
    type: complex
    update_time: '0.05'
    xmax: '1'
    xmin: '-1'
    ymax: '1'
    ymin: '-1'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: samp_rate
    color1: '"black"'
    fc: center_freq
    fftsize: '8192'
    grid: 'True'
    gui_hint: 0,0,1,1
    label1: '"filtered signal"'
    legend: 'False'
    name: Input Signal
    showports: 'True'
    type: complex
    update_time: '0.05'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-40'
    ymin: '-60'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '8192'
    gui_hint: 1,0,6,1
    int_max: '0'
    int_min: '-130'
    legend: 'False'
    showports: 'True'
    type: complex
    update_time: '0.02'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.5'
    decim: '1'
    gain: '1'
    ntaps: '361'
    samp_rate: samp_rate
    sym_rate: symbol_rate
    type: fir_filter_ccf
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: bb_input
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: bb_input
  states: {}

connections:
- [analog_agc_xx_0_0, '0', root_raised_cosine_filter_0, '0']
- [analog_rail_ff_0, '0', blocks_float_to_char_0, '0']
- [blocks_complex_to_float_1, '0', blocks_interleave_0, '1']
- [blocks_complex_to_float_1, '1', blocks_interleave_0, '0']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_float_to_char_0, '0', blocks_file_sink_0_0_0, '0']
- [blocks_interleave_0, '0', analog_rail_ff_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_throttle_0_0_1_0, '0']
- [blocks_throttle_0_0_1_0, '0', virtual_sink_0_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', blocks_complex_to_float_1, '0']
- [digital_clock_recovery_mm_xx_0, '0', qtgui_const_sink_x_0, '0']
- [digital_cma_equalizer_cc_0, '0', digital_costas_loop_cc_0, '0']
- [digital_costas_loop_cc_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [root_raised_cosine_filter_0, '0', digital_cma_equalizer_cc_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_waterfall_sink_x_0, '0']
- [virtual_source_0, '0', analog_agc_xx_0_0, '0']

metadata:
  file_format: 1
